## nemu/configs/riscv32-native_defconfig
```kconfig
CONFIG_ISA_riscv=y
CONFIG_TARGET_NATIVE_ELF=y
# CONFIG_TRACE is not set
CONFIG_MSIZE=0x10000
CONFIG_DEVICE=y
```
